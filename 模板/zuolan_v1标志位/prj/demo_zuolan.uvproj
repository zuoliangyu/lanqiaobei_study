# Keil uVision project demo_zuolan.uvproj, settings and files
target zuolan (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo_zuolan
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\driver;..\user
  group user
    ./: STARTUP.A51
    ../user/: main.c
  group driver
    ../driver/: ds1302.c iic.c init.c key.c led.c onewire.c seg.c uart.c ul.c
