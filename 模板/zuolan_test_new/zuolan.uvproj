# Keil uVision project zuolan.uvproj, settings and files
target zuolan (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: zuolan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\user
  group user
    ./user/: main.c
  group driver
    ./driver/: ds1302.c iic.c key.c led.c onewire.c seg.c uart.c ul.c init.c
