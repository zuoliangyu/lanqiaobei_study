# Keil uVision project zuolan.uvproj, settings and files
target zuolan (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: zuolan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\user
  group user
    ./: STARTUP.A51
    ./user/: main.c
  group driver
    ./driver/: Key.c Led.c Seg.c init.c ds1302.c iic.c
