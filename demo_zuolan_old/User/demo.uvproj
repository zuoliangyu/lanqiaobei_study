# Keil uVision project demo.uvproj, settings and files
target zuolan (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: zuolan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\driver;..\user
  group user
    ./: main.c
  group driver
    ../driver/: Key.c ds1302.c iic.c Led.c onewire.c Seg.c Uart.c Ultrasonic.c
