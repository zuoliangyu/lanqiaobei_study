# Keil uVision project test_ne555.uvproj, settings and files
target zuolan (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test_ne555
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: main.c
